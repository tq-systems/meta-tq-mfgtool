
LIC_FILES_CHKSUM = "file://Licenses/README;md5=c7383a594871c03da76b3707929d2919"

SRCREV = "96353961cf56c89e7b9b53ed7aeebdee937b8db9"
SRCBRANCH = "TQMaxx2-v2015.04-rel_imx_4.1.15_1.2.0_ga"
SRC_URI = "git://github.com/tq-systems/u-boot-tqmaxx.git;protocol=https;branch=${SRCBRANCH}"
